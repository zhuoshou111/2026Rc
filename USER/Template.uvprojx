# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\CONTRAL;..\HARDWARE\OLED;..\HARDWARE\UART;..\HARDWARE\SYSTEM_INIT;..\HARDWARE\SERVO;..\HARDWARE\COUNT;..\HARDWARE\CONTRAL_CLAW;..\HARDWARE\WS2812;..\HARDWARE\COLORRECO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c delay.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT README.md
  group HARDWARE
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/UART/: uart.c
    ../HARDWARE/CONTRAL/: contral.c
    ../HARDWARE/SYSTEM_INIT/: system_init.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/COUNT/: time_count.c
    ../HARDWARE/CONTRAL_CLAW/: contral_claw.c
    ../HARDWARE/WS2812/: ws2812.c
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Data.c OLED_Data.h
    ../HARDWARE/COLORRECO/: colorreco.c colorreco.h
    ../HARDWARE/CHASSIS/: chassis_mecanum.c chassis_mecanum.h
